<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\ProtoTest\ProtoTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Prototyp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


