# IAR project ProtoTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ProtoTest.srec
  ILINK.IlinkOutputFile: ProtoTest.out
  ILINK.IlinkIcfFile: C:\Users\Yobart\Documents\GitHub\Projekt\WiLCD\Prototyp\ProtoTest\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration Prototyp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s
  group Application/User
    ../Src/: func.c gpio.c i2c.c rtc.c stm32f3xx_hal_msp.c stm32f3xx_it.c usart.c
    ./: main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
